# Keil uVision project RTOS_RT.C.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: rtos +hex
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Files
    ./: RTOS_TX.C
  group Configuration
    ./: RTX_Config.c Startup.s
  group Documentation
    ./: Abstract.txt
